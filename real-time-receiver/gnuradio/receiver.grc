options:
  parameters:
    author: bodokaiser
    generate_options: qt_gui
    id: arduino
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: clock_freq
  id: variable_qtgui_range
  parameters:
    label: Clock Frequency
    orient: Qt.Horizontal
    start: 1e3
    step: '1'
    stop: 1e5
    value: 1e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: bypassed}
- name: analog_dpll_bb_0
  id: analog_dpll_bb
  parameters: {}
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: float
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '10'
    threshold_factor_fall: '0.40'
    threshold_factor_rise: '0.25'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.5'
    init: '0'
    low: '0.5'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-53e3'
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 10e3, 1e3, firdes.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    name: '"Filtered Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Filtered GA Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Raw Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_delay: '-1e-3'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: burst
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: Digital
    nconnections: '2'
    size: '1024'
    srate: samp_rate / decimation
    tr_delay: '-10e-3'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_peak_detector_xb_0, '0', blocks_char_to_short_0, '0']
- [blocks_threshold_ff_0, '0', blocks_burst_tagger_0, '0']
- [blocks_threshold_ff_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_2, '0']

metadata:
  file_format: 1

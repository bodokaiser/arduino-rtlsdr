options:
  parameters:
    author: bodokaiser
    generate_options: qt_gui
    id: arduino
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.6'
    init: '0'
    low: '0.3'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np

      from gnuradio import gr

      def bits_to_uint(bits):
          return np.dot(bits, 2**np.arange(len(bits))[::-1])


      class Parser:

          def __init__(self, sample_rate=16e3, sequence_timeout=5e-3, transmission_timeout=20e-3, on_width=1.0e-3, off_width=0.01e-3):
              self.bits = []
              self.values = []
              self.median = 0

              self.on_width = on_width
              self.off_width = off_width
              self.time_step = 1 / sample_rate

              self.sequence_timeout = sequence_timeout
              self.transmission_timeout = transmission_timeout

              self.low_time = 0
              self.high_time = 0

          def parse(self, samples):
              for sample in np.nditer(samples):
                  self.parse_sample(sample)

          def parse_sample(self, sample):
              if self.high_time == 0:
                  if sample == 0:
                      self.low_time += self.time_step

                      if self.low_time >= self.sequence_timeout:
                          if len(self.bits) == 0:
                              self.low_time = 0
                              return

                          self.values.append(bits_to_uint(self.bits))
                          self.bits = []

                          if len(self.values) == 10:
                              self.median = np.median(self.values).round().astype(np.uint)
                              self.low_time = 0
                              self.values = []
                              return


                  if sample == 1:
                      self.low_time = 0
                      self.high_time += self.time_step

              else:
                  if sample == 0:
                      if self.high_time >= self.on_width:
                          self.bits.append(1)
                      else:
                          if self.high_time >= self.off_width:
                              self.bits.append(0)

                      self.high_time = 0
                      self.low_time += self.time_step


                  if sample == 1:
                      self.high_time += self.time_step



      class ook_demod_block(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='OOK Demod',
                  in_sig=[np.float32],
                  out_sig=[np.uint8]
              )

              self.parser = Parser()

          def work(self, input_items, output_items):
              if input_items[0].sum() > 0:
                  self.parser.parse(input_items[0])

              if len(self.parser.values) > 0:
                  output_items[0] = self.parser.values[-1]
              else:
                  output_items[0] = 1
              
              return 1
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-53e3'
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 10e3, 1e3, firdes.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    name: '"Filtered Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Filtered GA Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Raw Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Decimal
    size: '1024'
    srate: samp_rate / decimation
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Analog"'
    size: '1024'
    srate: samp_rate / decimation
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: Digital
    size: '1024'
    srate: samp_rate / decimation
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:3000
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_threshold_ff_0, '0', zeromq_pub_sink_0, '0']
- [epy_block_0, '0', blocks_char_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_2, '0']

metadata:
  file_format: 1

options:
  parameters:
    generate_options: qt_gui
    id: clock_recovery
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: filter_freq
  id: variable_qtgui_range
  parameters:
    label: Filter Frequency
    orient: Qt.Horizontal
    start: 20e3
    step: 1e3
    stop: 500e3
    value: 80e3
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2048e3
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    label: Transition Width
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 100e3
    value: 20e3
  states: {}
- name: xlate_freq
  id: variable_qtgui_range
  parameters:
    label: Translating Frequency
    orient: Qt.Horizontal
    start: '-10000'
    step: '1'
    stop: '+10000'
    value: '-223'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/bodokaiser/Repositories/github.com/bodokaiser/arduino-rtlsdr/reverse-engineering/data/10111_11111.cu8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/255
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/255
    type: float
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '10'
    threshold_factor_fall: '0.40'
    threshold_factor_rise: '0.25'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.1'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_freq
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, filter_freq, trans_width, firdes.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: Xlated Signal
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Xlated Signal
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: Xlated Signal
    size: '1024'
    srate: samp_rate
    tr_delay: '100e-6'
    tr_level: '0.20'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Magnitude
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: Digital Signal
    size: '1024'
    srate: samp_rate / decimation
    tr_delay: '100e-6'
    tr_level: '0.20'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Magnitude
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Clock
    name: Clock
    size: '1024'
    srate: samp_rate / decimation
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: burst
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_float_to_complex_0, '1']
- [blocks_and_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_burst_tagger_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_burst_tagger_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_char_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0, '0']
- [blocks_deinterleave_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_uchar_to_float_1, '0']
- [blocks_file_source_0, '0', blocks_deinterleave_0, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_peak_detector_xb_0, '0', blocks_char_to_short_0, '0']
- [blocks_threshold_ff_0, '0', blocks_burst_tagger_0, '0']
- [blocks_threshold_ff_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_and_xx_0, '1']
- [digital_binary_slicer_fb_0_0, '0', blocks_and_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
